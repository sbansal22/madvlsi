v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 140 -110 170 -110 { lab=#net1}
N 100 -80 100 -70 { lab=VN}
N 100 -70 200 -70 { lab=VN}
N 200 -80 200 -70 { lab=VN}
N 100 -70 100 -60 { lab=VN}
N 200 -150 200 -140 { lab=VP}
N 100 -150 100 -140 { lab=VP}
N 100 -150 200 -150 { lab=VP}
N 240 -110 260 -110 { lab=Y}
N 100 -160 100 -150 { lab=VP}
N 40 -110 70 -110 { lab=A}
C {devices/ipin.sym} 40 -110 0 0 {name=p1 lab=A}
C {devices/iopin.sym} 100 -160 3 0 {name=p2 lab=VP}
C {devices/iopin.sym} 100 -60 1 0 {name=p3 lab=VN}
C {devices/opin.sym} 260 -110 0 0 {name=p4 lab=Y}
C {/home/madvlsi/Desktop/madvlsi/MP1/inverter.sym} 50 -110 0 0 {name=X1}
C {/home/madvlsi/Desktop/madvlsi/MP1/inverter.sym} 150 -110 0 0 {name=X2}
